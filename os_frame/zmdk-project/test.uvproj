# Keil uVision project test.uvproj, settings and files
target OS (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: ..\incs\asm-arm\stm32f10xx;..\incs\kernel;..\incs\driver;..\task\usertask;..\incs\driver\stm32f103x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep *.o(qShellVarTab)
--keep *.o(qShellFunTab)
  group boot
    ../arch/arm/stm32f10x/boot/: boot_stm32f10x_hd.s
    ../arch/arm/stm32f10x/startup/: start_up.c
  group arch
    ../arch/arm/stm32f10x/kernel/clock/: clock_arch.c
    ../arch/arm/stm32f10x/kernel/mm/: mem.c
    ../arch/arm/stm32f10x/kernel/systick/: systick.c
  group task
    ../task/systemtask/: Task.c
    ../task/usertask/: usertask.c
  group kernel
    ../kernel/clockmanager/: clockmanager.c
    ../kernel/message/: message.c
    ../kernel/object/: obj.c
    ../kernel/shedule/: os.c
    ../kernel/timer/: hal_timer.c
    ../kernel/devmngr/: device.c
  group drivers
    ../drivers/stm32f103x/char/usart/: usart1.c usart2.c
    ../drivers/stm32f103x/misc/ADC/: ADC.C
    ../drivers/stm32f103x/misc/keys/: keys.c
    ../drivers/stm32f103x/misc/LED/: led.c
    ../drivers/stm32f103x/misc/relay/: relay.c
    ../drivers/stm32f103x/misc/Time3/: Time3.c
  group shell
    ../kernel/Q_Shell/: cmd.c Q_Shell.c
