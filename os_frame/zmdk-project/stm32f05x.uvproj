# Keil uVision project stm32f05x.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: stm32f05x
  c misc: --C99
  c include: ..\incs\asm-arm\stm32f0xx;..\incs\kernel;..\incs\driver;..\incs\driver\stm32f051x;..\task\usertask;..\incs\driver\stm32f103x;..\xgui\Include;..\xgui\Include\Graphics
  asm include: ..\incs\driver\stm32f051x;..\incs\asm-arm;..\incs\kernel;..\incs\driver;..\task\usertask
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep *.o(qShellVarTab)
--keep *.o(qShellFunTab)
  group boot
    ../arch/arm/stm32f05x/boot/: startup_stm32f0xx.s
    ../arch/arm/stm32f05x/startup/: start_up.c
    ../arch/arm/stm32f05x/kernel/corefunc/: system_stm32f0xx.c
  group arch
    ../arch/arm/stm32f05x/kernel/clock/: clock_arch.c
    ../arch/arm/stm32f05x/kernel/mm/: mem.c
    ../arch/arm/stm32f05x/kernel/systick/: systick.c
    ../arch/arm/stm32f05x/kernel/gpio/: gpio_mgr.c
  group task
    ../task/systemtask/: system_task.c
    ../task/usertask/: manufacture_task.c user_task.c
    ../task/guitask/: gui_task.c
  group kernel
    ../kernel/clockmanager/: clockmanager.c
    ../kernel/devmngr/: device.c
    ../kernel/message/: message.c
    ../kernel/object/: obj.c
    ../kernel/shedule/: os.c
    ../kernel/timer/: hal_timer.c
    ../kernel/busmgr/: bus.c
    ../kernel/mtd/: mtd.c
  group drivers
    ../drivers/stm32f051x/char/usart/: usart1.c usart2.c
    ../drivers/stm32f051x/misc/keys/: keys.c
    ../drivers/stm32f051x/misc/LED/: led.c
    ../drivers/stm32f051x/misc/relay/: relay.c
    ../drivers/stm32f051x/bus/: spi2.c spi1.c
    ../drivers/stm32f051x/misc/lcd/: lcd.c
    ../drivers/stm32f051x/misc/me2_ch2o/: me2_ch2o.C
    ../drivers/stm32f051x/misc/htu20d/: htu20d.c
    ../drivers/stm32f051x/char/eeprom/: eeprom.c
    ../drivers/stm32f051x/char/flash/: w25qxx.c
  group shell
    ../kernel/Q_Shell/: cmd.c Q_Shell.c calibration.c
  group lib
    ../arch/arm/stm32f05x/lib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group gui
    ../xgui/Graphics/: Button.c CheckBox.c EditBox.c GOL.c GOLFontDefault.c Grid.c GroupBox.c ListBox.c Meter.c Picture.c Primitive.c ProgressBar.c RadioButton.c Slider.c SSD1303.c StaticText.c Template.c Window.c
